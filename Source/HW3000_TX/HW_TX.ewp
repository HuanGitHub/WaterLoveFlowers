# IAR project HW_TX.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L101F3P STM8L101F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\DRIVER\CPU\STM8L_LIB_V1.2.0\inc; ..\DRIVER\RF; ..\DRIVER\HW3000; ..\BSP; ..\DRIVER\DS3231\inc; ..\DRIVER\TM1650
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: HW_TX.hex
  ILINK.IlinkOutputFile: HW_TX.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    ./: FSM.c Key.c LED.c main.c Motor.c stm8l10x_it.c System.c Time.c
  group BSP
    ../BSP/: bsp.c
  group DEVICE/CPU
    ../DRIVER/CPU/STM8L_LIB_V1.2.0/src/: stm8l10x_awu.c stm8l10x_beep.c stm8l10x_clk.c stm8l10x_comp.c stm8l10x_exti.c stm8l10x_flash.c stm8l10x_gpio.c stm8l10x_i2c.c stm8l10x_irtim.c stm8l10x_itc.c stm8l10x_iwdg.c stm8l10x_rst.c stm8l10x_spi.c stm8l10x_tim2.c stm8l10x_tim3.c stm8l10x_tim4.c stm8l10x_usart.c stm8l10x_wfe.c
  group DEVICE/DS3231
    ../DRIVER/DS3231/src/: ds3231.c gpio.c i2c.c tm1621.c uart.c
  group DEVICE/HW3000
    ../DRIVER/HW3000/: hw3000.c
  group DEVICE/TM1650
    ../DRIVER/TM1650/: TM1650.C TM1650.h
