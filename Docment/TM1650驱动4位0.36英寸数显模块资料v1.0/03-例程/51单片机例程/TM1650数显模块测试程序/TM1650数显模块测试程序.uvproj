# Keil uVision project TM1650数显模块测试程序.uvproj, settings and files
target STC89C52 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODAT2
  output: TM1650数显模块测试程序 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: STARTUP.A51 Main.c
  group TM1650
    ./: tm1650.c
